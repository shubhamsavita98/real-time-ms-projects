# Keil uVision project project.uvprojx, settings and files
target Simulation (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Files
    ./: main.c usart2_driver.c usart2_driver.h sensor_ADC_driver.c sensor_ADC_driver.h button.c button.h led.c led.h
    ./TraceRecorder/: LICENSE.md README.md trcAssert.c trcCounter.c trcDependency.c trcDiagnostics.c trcEntryTable.c trcError.c trcEvent.c trcEventBuffer.c trcExtension.c trcHardwarePort.c trcHeap.c trcInternalEventBuffer.c trcInterval.c trcISR.c trcMultiCoreEventBuffer.c trcObject.c trcPrint.c trcRunnable.c trcSnapshotRecorder.c trcStackMonitor.c trcStateMachine.c trcStaticBuffer.c trcString.c trcTask.c trcTimestamp.c trcKernelPort.c trcStreamingRecorder.c
    ./TraceRecorder/config/: trcConfig.h trcKernelPortConfig.h trcKernelPortSnapshotConfig.h trcKernelPortStreamingConfig.h trcSnapshotConfig.h trcStreamingConfig.h
    ./TraceRecorder/include/: trcAssert.h trcCounter.h trcDefines.h trcDependency.h trcDiagnostics.h trcEntryTable.h trcError.h trcEvent.h trcEventBuffer.h trcExtension.h trcHardwarePort.h trcHeap.h trcInternalEventBuffer.h trcInterval.h trcISR.h trcKernelPort.h trcMultiCoreEventBuffer.h trcObject.h trcPrint.h trcProcess.h trcRecorder.h trcRunnable.h trcStackMonitor.h trcStateMachine.h trcStaticBuffer.h trcString.h trcTask.h trcThread.h trcTimestamp.h trcTypes.h trcUtility.h
    ./TraceRecorder/streamports/ARM_ITM/: trcStreamPort.c
    ./TraceRecorder/streamports/ARM_ITM/include/: trcStreamPort.h
    ./TraceRecorder/streamports/ARM_ITM/config/: trcStreamPortConfig.h
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: project +hex
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ../lib;../util;.\TraceRecorder\streamports\;.\TraceRecorder\config;.\TraceRecorder\include;.\TraceRecorder\streamports\ARM_ITM\config;.\TraceRecorder\streamports\ARM_ITM\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, Compiler:Event Recorder 1.5.1, Device:Startup 1.3.2
